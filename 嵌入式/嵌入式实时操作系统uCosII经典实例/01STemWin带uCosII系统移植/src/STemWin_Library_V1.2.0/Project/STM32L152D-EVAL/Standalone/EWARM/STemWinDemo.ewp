# IAR project STemWinDemo.ewp, settings and files
configuration STM32L152D-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM32L152D_EVAL; STM32L1XX_HD
  ICCARM.CCIncludePath2: ..\Config; ..\User; ..\Demo; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL; ..\..\..\..\Libraries\STemWinLibrary532\inc; ..\..\..\..\Libraries\STemWinLibrary532\Config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STemWinDemo_STM32L152D.hex
  ILINK.IlinkOutputFile: STM32L152D-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appli/Demo
    ../Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Appli/EWARM
    ./: startup_stm32l1xx_hd.s
  group Appli/User
    ../User/: bsp.c main.c stm32xxx_it.c system_stm32l1xx.c
  group Doc
    ../: readme.txt
  group Libraries/STemWin_V532/Config
    ../../../../Libraries/STemWinLibrary532/OS/: GUI_X.c
    ../Config/: GUIConf_stm32l152d_eval.c LCDConf_stm32l152d_eval.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM3_IAR.a
  group Libraries/STM32L152D-EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_fsmc_sram.c stm32l152d_eval_lcd.c
  group Libraries/STM32L1xx_StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
