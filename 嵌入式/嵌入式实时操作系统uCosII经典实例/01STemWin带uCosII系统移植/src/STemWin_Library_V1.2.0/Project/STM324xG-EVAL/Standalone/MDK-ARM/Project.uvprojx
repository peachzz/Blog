# Keil uVision project Project.uvprojx, settings and files
target STM324xG-EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324xG_EVAL,STM32F40XX
  c misc: --C99
  c include: ../Config;../User;../Demo;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Appli/MDK-ARM
    ./: startup_stm32f4xx.s
  group Appli/Demo
    ../Demo/: GUIDEMO_ImageFlow.c GUIDEMO_Cursor.c GUIDEMO_Bitmap.c GUIDEMO_IconView.c GUIDEMO_VScreen.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Speedometer.c GUIDEMO_Listview.c GUIDEMO_Treeview.c GUIDEMO_Skinning.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_BarGraph.c GUIDEMO_WashingMachine.c GUIDEMO_Graph.c GUIDEMO_Fading.c GUIDEMO.c GUIDEMO_Conf.c GUIDEMO_Intro.c GUIDEMO_AntialiasedText.c GUIDEMO_ColorBar.c GUIDEMO_Automotive.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_can.c stm32f4xx_spi.c stm32f4xx_cryp_des.c stm32f4xx_hash.c stm32f4xx_rtc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rng.c stm32f4xx_ltdc.c stm32f4xx_wwdg.c stm32f4xx_usart.c stm32f4xx_dma2d.c stm32f4xx_iwdg.c misc.c stm32f4xx_cryp_tdes.c stm32f4xx_i2c.c stm32f4xx_fmc.c stm32f4xx_sdio.c stm32f4xx_dcmi.c stm32f4xx_sai.c stm32f4xx_hash_sha1.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_cryp_aes.c stm32f4xx_cryp.c stm32f4xx_pwr.c stm32f4xx_dac.c stm32f4xx_rcc.c stm32f4xx_crc.c stm32f4xx_flash.c stm32f4xx_syscfg.c stm32f4xx_hash_md5.c stm32f4xx_tim.c stm32f4xx_dbgmcu.c
  group Appli/User
    ../User/: system_stm32f4xx.c stm32xxx_it.c main.c bsp.c
  group Libraries/STemWin_V532/Config
    ../Config/: LCDConf_stm3240g_eval.c GUIConf_stm3240g_eval.c
    ../../../../Libraries/STemWinLibrary532/OS/: GUI_X.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
  group Libraries/STM324xG-EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_sdio_sd.c stm324xg_eval_lcd.c stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_fsmc_sram.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
