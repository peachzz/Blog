# Keil uVision project Project.uvprojx, settings and files
target STM32L152D (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L152ZD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152D
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM32L152D_EVAL,STM32L1XX_HD
  c misc: --C99
  c include: ../Config;../User;../Demo;../../../../Libraries/STM32L1xx_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM32L152D_EVAL;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config;../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../../../Utilities/Third_Party/FreeRTOS/Source/include
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Appli/User
    ../User/: stm32xxx_it.c main.c bsp.c system_stm32l1xx.c
  group Libraries/STM32L152D-EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_lcd.c stm32l152d_eval_fsmc_sram.c
  group Appli/Demo
    ../Demo/: GUIDEMO_ColorBar.c GUIDEMO_Skinning.c GUIDEMO_Treeview.c GUIDEMO_AntialiasedText.c GUIDEMO_VScreen.c GUIDEMO_ZoomAndRotate.c GUIDEMO_BarGraph.c GUIDEMO_Fading.c GUIDEMO_WashingMachine.c GUIDEMO_RadialMenu.c GUIDEMO_ImageFlow.c GUIDEMO_IconView.c GUIDEMO_Listview.c GUIDEMO_Conf.c GUIDEMO_TransparentDialog.c GUIDEMO_Resource.c GUIDEMO_Automotive.c GUIDEMO_Intro.c GUIDEMO_Start.c GUIDEMO_Speedometer.c GUIDEMO_Cursor.c GUIDEMO.c GUIDEMO_Graph.c GUIDEMO_Speed.c GUIDEMO_Bitmap.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM3_OS_Keil.lib
  group Libraries/STM32L1xx_StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_tim.c stm32l1xx_rcc.c stm32l1xx_dac.c misc.c stm32l1xx_sdio.c stm32l1xx_flash_ramfunc.c stm32l1xx_spi.c stm32l1xx_gpio.c stm32l1xx_aes_util.c stm32l1xx_crc.c stm32l1xx_opamp.c stm32l1xx_flash.c stm32l1xx_rtc.c stm32l1xx_adc.c stm32l1xx_dma.c stm32l1xx_comp.c stm32l1xx_dbgmcu.c stm32l1xx_usart.c stm32l1xx_fsmc.c stm32l1xx_aes.c stm32l1xx_wwdg.c stm32l1xx_exti.c stm32l1xx_iwdg.c stm32l1xx_i2c.c stm32l1xx_syscfg.c stm32l1xx_pwr.c
  group Utilities/FreeRTOS/Portable/ARM_CM3
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port_cm3.c
  group Appli/MDK-ARM
    ./: startup_stm32l1xx_hd.s
  group Libraries/STemWin_V532/Config
    ../Config/: LCDConf_stm32l152d_eval.c GUIConf_stm32l152d_eval.c
  group Libraries/STemWin_V532/OS
    ../Config/: GUI_X_FreeRTOS.c
  group Utilities/FreeRTOS/Core
    ../../../../Utilities/Third_Party/FreeRTOS/Source/: timers.c tasks.c croutine.c queue.c list.c
  group Utilities/FreeRTOS/Memory
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
