# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\uCOS-II;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\uCOS-II\Ports;..\uCOS-II\uCOS-II\Source;..\uCOS-II\OS;..\BSP\inc;..\STemWin;..\STemWin\inc;..\STemWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/src/: bsp_debug_usart.c bsp_led.c bsp_lcd.c bsp_SysTick.c
  group USER
    ../User/: stm32f10x_it.c main.c
  group OS
    ../uCOS-II/OS/: app_hooks.c bsp.c
  group uCOS-II_CPU
    ../uCOS-II/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uCOS-II_LIB
    ../uCOS-II/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_mem_a.asm lib_str.c
  group uCOS-II_Ports
    ../uCOS-II/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II_Source
    ../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group DOC
    ../Doc/: Readme.txt
  group STemWin
    ../STemWin/Config/: GUIConf.c LCDConf.c
    ../STemWin/OS/: GUI_X_OS.c
    ../STemWin/Lib/: GUI_CM3_L.lib
