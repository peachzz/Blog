# IAR project STemWinDemo.ewp, settings and files
configuration STM324xG-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM324xG_EVAL; STM32F40XX
  ICCARM.CCIncludePath2: ..\Config; ..\User; ..\Demo; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\..\..\..\Libraries\STemWinLibrary532\inc; ..\..\..\..\Libraries\STemWinLibrary532\Config; ..\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\Utilities\Third_Party\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STemWinDemo_STM324xG_FreeRTOS.hex
  ILINK.IlinkOutputFile: STM324xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appli/Demo
    ../Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Appli/EWARM
    ./: startup_stm32f4xx.s
  group Appli/User
    ../User/: bsp.c main.c stm32xxx_it.c system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Libraries/STemWin_V532/Config
    ../Config/: GUIConf_stm3240g_eval.c LCDConf_stm3240g_eval.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM4_OS_IAR.a
  group Libraries/STemWin_V532/OS
    ../Config/: GUI_X_FreeRTOS.c
  group Libraries/STM324xG-EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_fsmc_sram.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c stm324xg_eval_sdio_sd.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Utilities/FreeRTOS/Core
    ../../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Utilities/FreeRTOS/Memory
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Utilities/FreeRTOS/Portable/ARM_CM4F
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port_cm4.c portasm_cm4.s
