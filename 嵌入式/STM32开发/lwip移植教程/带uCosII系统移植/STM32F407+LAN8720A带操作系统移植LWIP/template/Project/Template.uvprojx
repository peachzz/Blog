# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\uCosII;..\uCosII\uC-CPU;..\uCosII\uC-LIB;..\uCosII\uCOS-II\Ports;..\uCosII\uCOS-II\Source;..\uCosII\OS;..\BSP\inc;..\Lwip;..\Lwip\arch;..\Lwip\lwip_app;..\Lwip\lwip-2.1.1\src\include;..\Lwip\lwip-2.1.1\src\include\lwip;..\Lwip\lwip-2.1.1\src\include\lwip\apps;..\Lwip\lwip-2.1.1\src\include\lwip\priv;..\Lwip\lwip-2.1.1\src\include\lwip\prot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group FWLB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../BSP/src/: stm32f429_eth.c
  group BSP
    ../BSP/src/: bsp.c bsp_debug_usart.c bsp_SysTick.c LAN8742A.c
  group USER
    ../User/: main.c stm32f4xx_it.c
  group OS
    ../uCosII/OS/: app_hooks.c
  group uCOS-II_CPU
    ../uCosII/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uCOS-II_LIB
    ../uCosII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uCOS-II_Ports
    ../uCosII/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uCOS-II_Source
    ../uCosII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group lwip_app
    ../Lwip/lwip_app/: lwip_app.c
  group lwip_arch
    ../Lwip/arch/: sys_arch.c
  group lwip
    ../Lwip/lwip-2.1.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Lwip/lwip-2.1.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Lwip/lwip-2.1.1/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip_netif
    ../Lwip/lwip-2.1.1/src/netif/: ethernet.c
    ../Lwip/lwip_app/: ethernetif.c
  group DOC
    ../Doc/: Readme.txt
