# Keil uVision project Project.uvprojx, settings and files
target STM324x9I-EVAL-MB1046 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.2
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I-EVAL-MB1046
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324x9I_EVAL,STM32F429_439xx,USE_MB1046
  c misc: --C99
  c include: ../Config;../User;../Demo;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM324x9I_EVAL;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config;../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../Utilities/Third_Party/FreeRTOS/Source/include;../../../../Libraries/STM32F4x7_ETH_Driver/inc;../../../../Utilities/Third_Party/lwip-1.4.1/src/include;../../../../Utilities/Third_Party/lwip-1.4.1/src/include/lwip;../../../../Utilities/Third_Party/lwip-1.4.1/src/include/netif;../../../../Utilities/Third_Party/lwip-1.4.1/src/include/ipv4;../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7;../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7/FreeRTOS
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Utilities/FreeRTOS/Portable/ARM_CM4F
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port_cm4.c
  group Appli/User
    ../User/: netconf.c stm32xxx_it.c main.c system_stm32f4xx.c bsp.c GUI_VNC_X_StartServer.c stm32f4xx_eth_bsp.c
  group Utilities/LwIP/Core/IPv4
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: ip.c igmp.c autoip.c inet.c ip_frag.c inet_chksum.c ip_addr.c icmp.c
  group Libraries/STemWin_V532/OS
    ../Config/: GUI_X_FreeRTOS.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM4_OS_Keil.lib
  group Utilities/LwIP/Core
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/: dhcp.c tcp_out.c init.c dns.c def.c netif.c mem.c tcp.c lwip_timers.c raw.c udp.c memp.c tcp_in.c pbuf.c stats.c sys.c
  group Utilities/FreeRTOS/Memory
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Utilities/LwIP/Netif
    ../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: sys_arch.c ethernetif.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_exti.c stm32f4xx_dac.c misc.c stm32f4xx_fmc.c stm32f4xx_sdio.c stm32f4xx_hash_md5.c stm32f4xx_rng.c stm32f4xx_cryp_tdes.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_adc.c stm32f4xx_hash.c stm32f4xx_dbgmcu.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_cryp.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_iwdg.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_hash_sha1.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_cryp_des.c stm32f4xx_dcmi.c stm32f4xx_pwr.c stm32f4xx_cryp_aes.c stm32f4xx_crc.c stm32f4xx_sai.c stm32f4xx_wwdg.c stm32f4xx_usart.c
  group Libraries/STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Utilities/FreeRTOS/Core
    ../../../../Utilities/Third_Party/FreeRTOS/Source/: timers.c tasks.c croutine.c queue.c list.c
  group Utilities/LwIP/Api
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/api/: netifapi.c sockets.c tcpip.c netdb.c api_lib.c api_msg.c err.c netbuf.c
  group Libraries/STM324x9I-EVAL
    ../../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_lcd.c stm324x9i_eval_ioe8.c stm324x9i_eval_sdio_sd.c stm324x9i_eval_fmc_sram.c stm324x9i_eval_fmc_sdram.c stm324x9i_eval_ioe16.c
  group Libraries/STemWin_V532/Config
    ../Config/: LCDConf_stm324x9i_eval_MB1063.c GUIConf_stm324x9i_eval.c LCDConf_stm324x9i_eval_MB1046.c
  group Appli/Demo
    ../Demo/: GUIDEMO_ImageFlow.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Speedometer.c GUIDEMO_WashingMachine.c GUIDEMO_RadialMenu.c GUIDEMO.c GUIDEMO_Fading.c GUIDEMO_ZoomAndRotate.c GUIDEMO_VScreen.c GUIDEMO_Vnc.c GUIDEMO_Cursor.c GUIDEMO_Bitmap.c GUIDEMO_Resource.c GUIDEMO_Intro.c GUIDEMO_Speed.c GUIDEMO_TransparentDialog.c GUIDEMO_Graph.c GUIDEMO_Start.c GUIDEMO_Listview.c GUIDEMO_BarGraph.c GUIDEMO_Skinning.c GUIDEMO_IconView.c GUIDEMO_Treeview.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c
  group Appli/MDK-ARM
    ./: startup_stm32f429x.s
  group Doc
    ../: readme.txt
target STM324x9I-EVAL-MB1063 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.2
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324x9I-EVAL-MB1063
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324x9I_EVAL,STM32F429_439xx,USE_MB1063
  c misc: --C99
  c include: ../Config;../User;../Demo        ;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM324x9I_EVAL;../../../../Utilities/Third_Party/fat_fs/inc;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config;../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../Utilities/Third_Party/FreeRTOS/Source/include
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
