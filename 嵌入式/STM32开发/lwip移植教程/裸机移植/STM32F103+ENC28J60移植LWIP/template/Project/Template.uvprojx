# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\BSP\inc;..\Lwip;..\Lwip\arch;..\Lwip\lwip_app;..\Lwip\lwip-2.1.1\src;..\Lwip\lwip-2.1.1\src\include;..\Lwip\lwip-2.1.1\src\include\lwip;..\Lwip\lwip-2.1.1\src\include\lwip\priv;..\Lwip\lwip-2.1.1\src\include\lwip\apps;..\Lwip\lwip-2.1.1\src\include\lwip\prot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/src/: bsp_SysTick.c ENC28J60.C SPI.C bsp_debug_usart.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group Lwip_app
    ../Lwip/lwip-2.1.1/src/apps/mqtt/: mqtt.c
    ../Lwip/lwip_app/: lwip_app.c
  group Lwip_netif
    ../Lwip/lwip_app/: ethernetif.c
  group Lwip_arch
    ../Lwip/arch/: sys_arch.c
  group Lwip
    ../Lwip/lwip-2.1.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Lwip/lwip-2.1.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Lwip/lwip-2.1.1/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Lwip/lwip-2.1.1/src/netif/: ethernet.c
  group DOC
    ../Doc/: Readme.txt
