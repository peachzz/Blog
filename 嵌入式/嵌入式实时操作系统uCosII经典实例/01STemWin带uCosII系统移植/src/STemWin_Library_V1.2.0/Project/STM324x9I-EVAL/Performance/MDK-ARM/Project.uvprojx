# Keil uVision project Project.uvprojx, settings and files
target STM324x9I-EVAL-MB1046 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.2
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324x9I-EVAL-MB1046
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324x9I_EVAL,STM32F429_439xx,USE_MB1046
  c misc: --C99
  c include: ../Config;../User;../Demo;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM324x9I_EVAL;../../../../Libraries/STemWinLibrary532/inc;../../../../Libraries/STemWinLibrary532/Config
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Libraries/STemWin_V532/Config
    ../Config/: GUIConf_stm324x9i_eval.c LCDConf_stm324x9i_eval_MB1046.c
    ../../../../Libraries/STemWinLibrary532/OS/: GUI_X.c
  group Appli/User
    ../User/: main.c system_stm32f4xx.c bsp.c stm32xxx_it.c BASIC_DriverPerformance.c
  group Libraries/STM324x9I-EVAL
    ../../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_sdio_sd.c stm324x9i_eval_lcd.c stm324x9i_eval_ioe8.c stm324x9i_eval_fmc_sram.c stm324x9i_eval_ioe16.c stm324x9i_eval_fmc_sdram.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_hash.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_dbgmcu.c stm32f4xx_dac.c stm32f4xx_pwr.c stm32f4xx_fmc.c stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_dma2d.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_hash_md5.c stm32f4xx_sai.c stm32f4xx_ltdc.c stm32f4xx_cryp.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_cryp_des.c stm32f4xx_syscfg.c misc.c stm32f4xx_hash_sha1.c stm32f4xx_usart.c stm32f4xx_dcmi.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_rng.c stm32f4xx_rcc.c stm32f4xx_cryp_aes.c stm32f4xx_sdio.c stm32f4xx_flash.c stm32f4xx_cryp_tdes.c stm32f4xx_crc.c stm32f4xx_rtc.c
  group Libraries/STemWin_V532/Lib
    ../../../../Libraries/STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
  group Appli/MDK-ARM
    ./: startup_stm32f429x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
